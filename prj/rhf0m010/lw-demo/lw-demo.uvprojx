# Keil uVision project lw-demo.uvprojx, settings and files
target NDebug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L072CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lw-demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L072xx,USE_FULL_LL_DRIVER,REGION_CN470
  c include: ..\..\..\src\apps\LoRaMac\classA\RHF76-052DM;..\..\..\src\apps\LoRaMac\common;..\..\..\src\apps\LoRaMac\common\LmHandler;..\..\..\src\apps\LoRaMac\common\LmHandler\packages;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\EEPROM_Emul\Core;..\..\..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\Inc;..\..\..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\Inc\Legacy;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards;..\..\..\src\boards\RHF0M010;..\..\..\src\boards\RHF0M010\cmsis;..\..\..\src\mac;..\..\..\src\mac\region;..\..\..\src\peripherals\soft-se;..\..\..\src\radio;..\..\..\src\radio\sx1276;..\..\..\src\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group apps
    ../../../src/apps/LoRaMac/classA/RHF76-052DM/: main.c
    ../../../src/apps/LoRaMac/common/: NvmCtxMgmt.c
  group board/mcu
    ../../../src/boards/mcu/: utilities.c
    ../../../src/boards/RHF0M010/: adc-board.c board.c delay-board.c eeprom-board.c gpio-board.c i2c-board.c lpm-board.c rtc-board.c spi-board.c sx1276-board.c uart-board.c
    ../../../src/boards/RHF76-052DM/cmsis/: system_stm32l0xx.c
    ../../../src/boards/RHF76-052DM/cmsis/arm-std/: startup_stm32l072xx.s
  group board/hal-drv
    ../../../src/boards/mcu/stm32/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
  group lorawan/mac
    ../../../src/mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
    ../../../src/peripherals/soft-se/: aes.c cmac.c soft-se.c
  group lorawan/region
    ../../../src/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group radio
    ../../../src/radio/sx1276/: sx1276.c
  group system
    ../../../src/system/: adc.c delay.c eeprom.c fifo.c gpio.c i2c.c nvmm.c systime.c timer.c uart.c
